# Keil uVision project FoodComputerARM-alpha.uvprojx, settings and files
target FoodComputerARM-alpha (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: FoodComputerARM-alpha
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __MBED__=1, DEVICE_I2CSLAVE=1, TARGET_LIKE_MBED, TARGET_NUCLEO_F401RE, TARGET_RTOS_M4_M7, DEVICE_RTC=1, TOOLCHAIN_object, TARGET_STM32F4, __CMSIS_RTOS, TARGET_CORTEX_M, TARGET_LIKE_CORTEX_M4, TARGET_M4, TARGET_UVISOR_UNSUPPORTED, MBED_BUILD_TIMESTAMP=1469721822, DEVICE_PWMOUT=1, DEVICE_INTERRUPTIN=1, DEVICE_I2C=1, DEVICE_PORTOUT=1, __CORTEX_M4, DEVICE_STDIO_MESSAGES=1, TARGET_STM32F401RE, TARGET_FF_MORPHO, __FPU_PRESENT=1, TARGET_FF_ARDUINO, DEVICE_PORTIN=1, TARGET_RELEASE, TARGET_STM, DEVICE_SERIAL_FC=1, DEVICE_PORTINOUT=1, __MBED_CMSIS_RTOS_CM, DEVICE_SLEEP=1, DEVICE_SPI=1, TOOLCHAIN_ARM_STD, DEVICE_SPISLAVE=1, DEVICE_ANALOGIN=1, DEVICE_SERIAL=1, DEVICE_ERROR_RED=1, TOOLCHAIN_ARM, ARM_MATH_CM4, __ASSERT_MSG
  c misc: --restrict --multibyte_chars --apcs=interwork -c -O3 -Otime --brief_diagnostics --cpu=Cortex-M4.fp -D__ASSERT_MSG --no_depend_system_headers --preinclude=mbed_config.h --md --split_sections --no_rtti --gnu
  c include: .; DHT; DS18B20; DS18B20/DS1820; MODSERIAL; MODSERIAL/Device; ModbusSlave232; SoftSerial; TSL2561_I2C; millis; mbed; mbed/TARGET_NUCLEO_F401RE; mbed/TARGET_NUCLEO_F401RE/TARGET_STM; mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4; mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE; mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_STD
  asm misc: --cpreproc --cpreproc_opts=-D__MBED__=1,-DDEVICE_I2CSLAVE=1,-DTARGET_LIKE_MBED,-DTARGET_NUCLEO_F401RE,-DTARGET_RTOS_M4_M7,-DDEVICE_RTC=1,-DTOOLCHAIN_object,-DTARGET_STM32F4,-D__CMSIS_RTOS,-DTARGET_CORTEX_M,-DTARGET_LIKE_CORTEX_M4,-DTARGET_M4,-DTARGET_UVISOR_UNSUPPORTED,-DMBED_BUILD_TIMESTAMP=1469721822,-DDEVICE_PWMOUT=1,-DDEVICE_INTERRUPTIN=1,-DDEVICE_I2C=1,-DDEVICE_PORTOUT=1,-D__CORTEX_M4,-DDEVICE_STDIO_MESSAGES=1,-DTARGET_STM32F401RE,-DTARGET_FF_MORPHO,-D__FPU_PRESENT=1,-DTARGET_FF_ARDUINO,-DDEVICE_PORTIN=1,-DTARGET_RELEASE,-DTARGET_STM,-DDEVICE_SERIAL_FC=1,-DDEVICE_PORTINOUT=1,-D__MBED_CMSIS_RTOS_CM,-DDEVICE_SLEEP=1,-DDEVICE_SPI=1,-DTOOLCHAIN_ARM_STD,-DDEVICE_SPISLAVE=1,-DDEVICE_ANALOGIN=1,-DDEVICE_SERIAL=1,-DDEVICE_ERROR_RED=1,-DTOOLCHAIN_ARM,-DARM_MATH_CM4,-D__ASSERT_MSG
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_STD/stm32f401xe.sct
  group DHT
    DHT/: DHT.cpp DHT.h
  group DS18B20/DS1820
    DS18B20/DS1820/: DS1820.cpp DS1820.h
  group MODSERIAL
    MODSERIAL/: ChangeLog.c example1.cpp example2.cpp example3a.cpp example3b.cpp FLUSH.cpp GETC.cpp INIT.cpp ISR_RX.cpp ISR_TX.cpp MACROS.h MODSERIAL.cpp MODSERIAL.h MODSERIAL_IRQ_INFO.cpp PUTC.cpp RESIZE.cpp
  group MODSERIAL/Device
    MODSERIAL/Device/: AddingDevice.h MODSERIAL_KL05Z.cpp MODSERIAL_KL05Z.h MODSERIAL_KL25Z.cpp MODSERIAL_KL25Z.h MODSERIAL_KSDK.cpp MODSERIAL_KSDK.h MODSERIAL_LPC11U24.cpp MODSERIAL_LPC11U24.h MODSERIAL_LPC1768.cpp MODSERIAL_LPC1768.h MODSERIAL_NUCLEO_F401RE.cpp MODSERIAL_NUCLEO_F401RE.h MODSERIAL_PAC_F401RB.cpp MODSERIAL_PAC_F401RB.h
  group ModbusSlave232
    ModbusSlave232/: ModbusSlave232.cpp ModbusSlave232.h
  group SoftSerial
    SoftSerial/: SoftSerial.cpp SoftSerial.h SoftSerial_rx.cpp SoftSerial_Ticker.h SoftSerial_tx.cpp
  group Source_Files
    ./: includes.h main.cpp objects_and_variables.h pin_definitions.h
  group TSL2561_I2C
    TSL2561_I2C/: TSL2561_I2C.cpp TSL2561_I2C.h
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
  group mbed/TARGET_NUCLEO_F401RE
    mbed/TARGET_NUCLEO_F401RE/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h hal_tick.h stm32_hal_legacy.h stm32f401xe.h stm32f4xx.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h system_stm32f4xx.h
  group mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4
    mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/: gpio_object.h PeripheralPins.h
  group mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE
    mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE/: device.h objects.h PeripheralNames.h PinNames.h PortNames.h
  group mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_STD
    mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o hal_tick.o mbed.ar mbed_overrides.o retarget.o startup_stm32f401xe.o stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_can.o stm32f4xx_hal_cec.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_cryp.o stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_dsi.o stm32f4xx_hal_eth.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_flash_ramfunc.o stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.o stm32f4xx_hal_lptim.o stm32f4xx_hal_ltdc.o stm32f4xx_hal_ltdc_ex.o stm32f4xx_hal_msp_template.o stm32f4xx_hal_nand.o stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.o stm32f4xx_hal_smartcard.o stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.o stm32f4xx_hal_sram.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.o stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.o stm32f4xx_ll_sdmmc.o stm32f4xx_ll_usb.o sys.o system_stm32f4xx.o
  group millis
    millis/: millis.cpp millis.h
